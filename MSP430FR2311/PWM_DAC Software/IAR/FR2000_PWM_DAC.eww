<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\Workspace_IAR\PWM_DAC.ewp</path>
    </project>
    <batchBuild />
</workspace>
